# Keil uVision project nucleoF411.uvprojx, settings and files
target nucleoF411 Configuration (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: nucleoF411 Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,,STM32F411xE
  c misc: --C99 --cpp
  c include: ..\Drivers\STM32F4xx_HAL_Driver\Inc;   ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;   ..\Middlewares\Third_Party\FatFs\src;   ..\Middlewares\Third_Party\FatFs\src\drivers;   ..\Drivers\CMSIS\Include;   ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;   ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: fatfs.c user_diskio.c stm32f4xx_it.c stm32f4xx_hal_msp.c bsp_driver_sd.c main.cpp daq.cpp daq.hpp daqADS1298.cpp daqADS1298.hpp main.hpp myfputc.h
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ex.c
